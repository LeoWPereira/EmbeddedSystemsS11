# IAR project ExerciciosAula.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Modelo_C_asm_IAR7.out
  ILINK.IlinkIcfFile: C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\ExerciciosAula\ExerciciosAula.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    src/: exercicio07.s main.c main.h
