# IAR project Lib_EaBaseBoard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\EA_Base_Board_IAR7\Lib_MCU\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lib_EaBaseBoard.srec
  ILINK.IlinkOutputFile: Lib_EaBaseBoard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: acc.c eeprom.c flash.c font5x7.c joystick.c led7seg.c light.c oled.c pca9532.c rgb.c rotary.c temp.c uart2.c
