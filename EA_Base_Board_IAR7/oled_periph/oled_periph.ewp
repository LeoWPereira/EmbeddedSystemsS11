# IAR project oled_periph.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: oled_periph.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Lib_EaBaseBoard/Debug/Exe/: Lib_EaBaseBoard.a
    ../Lib_MCU/Debug/Exe/: Lib_MCU.a
    src/: main.c
    ../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
