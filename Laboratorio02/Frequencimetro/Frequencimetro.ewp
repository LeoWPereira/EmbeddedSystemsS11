# IAR project Frequencimetro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.PreInclude: C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\Laboratorio02\Frequencimetro\src\main.h
  ICCARM.CCIncludePath2: ..; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Core\Include; src\Auxiliares; src\Control; src\Encoder; src\GUI; src\PWM; src\Timer; C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\CMSIS_RTOS_IAR8\RTOS\RTX\SRC; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Core\Include; C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\Laboratorio02\Frequencimetro\src\Timer; C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\Laboratorio02\Frequencimetro\src\Auxiliares; C:\Users\leona\Documents\Personal_Projects\EmbeddedSystemsS11\CMSIS_RTOS_IAR8\RTOS\RTX\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/Auxiliares/: Auxiliar.c
    src/Control/: control.c
    src/Encoder/: encoder.c
    src/GPIO/: gpio.c
    src/GUI/: gui.c
    src/: main.c
    src/PWM/: pwm.c
    src/Timer/: Timer.c
  group Configs
    src/: RTX_Conf_CM.c
    ../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
  group Libraries
    ../Lib_EaBaseBoard/Debug/Exe/: Lib_EaBaseBoard.a
    ../Lib_MCU/Debug/Exe/: Lib_MCU.a
    ../../CMSIS_RTOS_IAR8/RTOS/RTX/SRC/IAR/CM3_LE/: RTX_Lib_CM.a
