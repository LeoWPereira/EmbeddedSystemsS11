<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Frequencimetro\Frequencimetro.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lib_EaBaseBoard\Lib_EaBaseBoard.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lib_MCU\Lib_MCU.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\oled_periph\oled_periph.ewp</path>
    </project>
    <batchBuild />
</workspace>
